# Keil uVision project OSD_N32G030.uvprojx, settings and files
target Debug (6180000::V6.18::ARMCLANG)
  device: N32G030K6 Nationstech
  pack: Nationstech.N32G030_DFP.1.0.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NBD_OSD_DEBUG +hex
  AfterMake: fromelf.exe --bin --output $L@L.bin $L@L.axf
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: N32G030, USE_STDPERIPH_DRIVER,_DEBUG_MODE
  c include: ..\Drivers\N32G030_StdPeriph_Driver\inc;..\Core\Inc;..\Core\middleware\cvbs_capture;..\Core\middleware\simulate_max7456;..\Core\middleware\simulate_max7456\font;..\Core\middleware\dynamic_vtx\pid;..\Core\middleware\dynamic_vtx;..\Core\middleware\encryption
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../Core/Src/: n32g030_it.c user_flash.c user_encryption.c main.c
  group Middleware
    ../Core/middleware/cvbs_capture/: cvbs.c
    ../Core/middleware/dynamic_vtx/pid/: PID.c
    ../Core/middleware/dynamic_vtx/: vtx.c
    ../Core/middleware/encryption/: encryption.c
    ../Core/middleware/simulate_max7456/: max7456.c
  group Libraries
    ../Drivers/N32G030_StdPeriph_Driver/src/: misc.c n32g030_adc.c n32g030_beeper.c n32g030_comp.c n32g030_crc.c n32g030_dbg.c n32g030_dma.c n32g030_exti.c n32g030_flash.c n32g030_gpio.c n32g030_hdiv.c n32g030_i2c.c n32g030_iwdg.c n32g030_lptim.c n32g030_lpuart.c n32g030_opamp.c n32g030_pwr.c n32g030_rcc.c n32g030_rtc.c n32g030_spi.c n32g030_sqrt.c n32g030_tim.c n32g030_usart.c n32g030_wwdg.c
  group Startup
    ../Core/Src/: system_n32g030.c
    ./: startup_n32g030.s
target Release (6180000::V6.18::ARMCLANG)
  device: N32G030K6 Nationstech
  pack: Nationstech.N32G030_DFP.1.0.2
  cpu: as above
  output: NBD_OSD +hex
  AfterMake: fromelf.exe --bin --output $L@L.bin $L@L.axf
  AfterMake: D:\WorkSpace\Newbeedrone\software\osd_n32g030\MDK-ARM\osd_vtx_nbd.bat
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: N32G030, USE_STDPERIPH_DRIVER
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.5.0
